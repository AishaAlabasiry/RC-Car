# Keil uVision project rc_car.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rc_car
  c flags: Optim=1 wLevel=2
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c tm4c123gh6pm.h
  group ::Device
    RTE/Device/TM4C123GH6PM/: startup_TM4C123.s system_TM4C123.c
software components: Device:Startup 1.0.0
